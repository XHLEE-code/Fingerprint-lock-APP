# Keil uVision project PWM.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\PWM;..\HARDWARE\DS3231;..\HARDWARE\OLED;..\HARDWARE\UltrasonicWave;..\HARDWARE\Key;..\HARDWARE\MPU6050;..\HARDWARE\AD-MQ;..\HARDWARE\Beep;..\HARDWARE\qxjc;..\HARDWARE\HW;..\HARDWARE\DHT11;..\HARDWARE\GPIO;..\HARDWARE\Rfid;..\HARDWARE\SG90;..\HARDWARE\SHAKE;..\HARDWARE\RTHW;..\HARDWARE\GPS;..\HARDWARE\PM25;..\HARDWARE\L298N;..\HARDWARE\Fire;..\HARDWARE\Gmdz;..\HARDWARE\HX711;..\HARDWARE\ESP8266;..\HARDWARE\AS608;..\HARDWARE\STMFLASH;..\HARDWARE\KEY-EEPROM;..\HARDWARE\bluetooth
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/OLED/: OLED.C
    ../HARDWARE/Key/: key.c
    ../HARDWARE/Beep/: BEEP.C
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/ESP8266/: ESP8266.c
    ../HARDWARE/AS608/: AS608.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/KEY-EEPROM/: KEYEEPROM.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_flash.c
  group README
    ../: README.TXT
